# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CmBacktrace +hex
  AfterMake: D:\keil MDK\ARM\ARMCC\bin\fromelf.exe  --bin -o "$LTemplate.bin" "#L"
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\CMSIS\Inc;..\Drives\Inc;..\FWLIB\Inc;..\FWLIB\SystemInc;..\Interrupt\Inc;..\task\Inc;..\UCOSIII\uc-BSP\Inc;..\UCOSIII\uC-LIB\Inc;..\UCOSIII\uC-CPU\Inc;..\UCOSIII\uC-CONFIG\Inc;..\UCOSIII\uCOS-III\Inc;..\BSP\Inc;..\modbus\ascii\Inc;..\modbus\BARE\Inc;..\modbus\include\Inc;..\modbus\rtu\Inc;..\modbus\tcp\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Project
    ./: main.c
  group BSP
    ../BSP/Src/: Sysbsp.c
  group Task
    ../task/Src/: task.c
  group System
    ../Drives/Src/: delay.c led.c sys.c usart.c
  group modbus
    ../modbus/ascii/Src/: mb.c mbascii.c
    ../modbus/rtu/Src/: mbrtu.c mbcrc.c
    ../modbus/functions/Src/: mbutils.c mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c
  group modbus port
    ../modbus/BARE/Src/: demo.c portevent.c portserial.c porttimer.c
  group Interrupt
    ../Interrupt/Src/: stm32f10x_it.c
  group FWLIB
    ../FWLIB/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../FWLIB/SystemSrc/: system_stm32f10x.c
  group StartUp
    ../FWLIB/StartUp/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/Src/: core_cm3.c
  group uC-LIB
    ../UCOSIII/uC-LIB/Src/: lib_str.c lib_ascii.c lib_math.c lib_mem.c lib_mem_a.asm
  group uC-BSP
    ../UCOSIII/uc-BSP/Src/: bsp.c
  group uC-CPU
    ../UCOSIII/uC-CPU/Src/: cpu_a.asm cpu_c.c cpu_core.c
  group uC-USER
    ../UCOSIII/uCOS-III/User/: os_cpu_c.c os_cpu_a.asm
  group uC-CONFIG
    ../UCOSIII/uC-CONFIG/Inc/: lib_cfg.h os_cfg.h app_cfg.h includes.h cpu_cfg.h os_cfg_app.h os_app_hooks.h
  group uC-UCOSIII
    ../UCOSIII/uCOS-III/Src/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
software components: CMSIS:CORE 5.0.1
